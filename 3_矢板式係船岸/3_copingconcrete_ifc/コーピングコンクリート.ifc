Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture]
Time: 2022-04-04T11:17:32
Author: J70738
Written by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016
Made in: Autodesk Civil 3D 2021 - 日本語 (Japanese) Build 13.3.854.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 4 11:17:32 2022 * Host: mn-kanaya02 * Database: C:\Users\J70738\AppData\Local\Temp\ACAIFCTMP/EDM27104\aec_ifc_db * Database version: 5507 * Database creation date: Mon Apr 4 09:39:11 2022 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Mon Apr 4 11:17:31 2022 * Header model: DataRepository.AecIfc_Header * Header model creation date: Mon Apr 4 11:17:31 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5649 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 1
LongName: コーピングコンクリート
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, コーピングコンクリート
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
